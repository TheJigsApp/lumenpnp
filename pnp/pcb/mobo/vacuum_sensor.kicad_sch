File: pnp/pcb/mobo/vacuum_sensor.kicad_sch (KiCad schematic)
At the start: 2 parts, among them U2 XGZP6857D

Commit message: porting version
Parts:
- renumbered C23 to C?, U2 to U?
